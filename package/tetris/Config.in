## package/tetris/Config.in
```kconfig
config BR2_PACKAGE_TETRIS
    bool "tetris"
    help
        tetris package.

        https://github.com/troglobit/tetris
```
